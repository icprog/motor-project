# IAR project mpgL1Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3U2C Atmel SAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U2C__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\src\bsp; ..\src\app; ..\src\lib\utils; ..\src\lib\structures\src; ..\src\lib\file; ..\src\lib\file\hooks\FatFs; ..\src\lib\file\disk; ..\src\lib\version; ..\src\lib\FatFs; ..\src\bsp; ..\src\config; ..\src\drivers; ..\src\utils; ..\src\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mpgL1Demo.srec
  ILINK.IlinkOutputFile: mpgL1Demo.out
  ILINK.IlinkIcfFile: sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UnitTests (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: UNIT_TESTING=1
  ICCARM.CCIncludePath2: ..\src; ..\src\lib\embUnit; ..\src\app; ..\src\lib\utils; ..\src\lib\structures\src; ..\src\lib\structures\unitTests; ..\src\lib\file; ..\src\lib\file\hooks\FatFs; ..\src\lib\file\disk; ..\src\lib\FatFs; ..\src\bsp; ..\src\config; ..\src\drivers; ..\src\utils; ..\src\drivers
  group (top)
    ../src/: main.c
  group app
    ../src/app/: demo.c motorControl.c
  group bsp
    ../src/bsp/: board_cstartup_iar.c bsp.c gpio.c irq.c time.c xgetdst.c
  group drivers
    ../src/drivers/: beeper.c button.c i2c.c lcd.c led.c rtc.c sd.c solenoid.c tact.c timer.c usart.c wdt.c
  group lib/embUnit
    ../src/lib/embUnit/embUnit/: AssertImpl.c RepeatedTest.c stdImpl.c TestCaller.c TestCase.c TestResult.c TestRunner.c TestSuite.c
    ../src/lib/embUnit/textui/: CompilerOutputter.c TextOutputter.c TextUIRunner.c
  group lib/FatFs
    ../src/lib/FatFs/option/: ccsbcs.c
    ../src/lib/FatFs/: ff.c
  group lib/file
    ../src/lib/file/: file.c
    ../src/lib/file/hooks/FatFs/: fileFat.c
    ../src/lib/file/disk/: fileSystem.c
  group lib/structures
    ../src/lib/structures/src/: circularBuffer.c itemQ.c
  group lib/utils
    ../src/lib/utils/: futils.c threadUtils.c utils.c
  group lib/version
    ../src/lib/version/: version.c
  group unitTests
    ../src/lib/structures/unitTests/: circularBufferTest.c itemQTest.c
    ../src/unitTests/: unitTests.c
  group utils
    ../src/utils/: sysTick.c
